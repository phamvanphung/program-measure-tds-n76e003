# Keil uVision project TSD_Step.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: TSD_Step +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\TDS_PHUONG_PHAP_STEP;.\lib;.\startup;.\user
  group user
    ./user/: main.c task.c task.h
  group lib
    ./lib/: Common.c Delay.c directer_time.c directer_time.h simplekalman.c
  group startup
    ./startup/: STARTUP.A51
